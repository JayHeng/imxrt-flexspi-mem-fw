# IAR project mtu_fw.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../src; ../../../../../devices/MIMXRT685S/utilities/debug_console_lite; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S; ../../../../../components/uart; ../../../flash_config; ../../../../../components/lists; ../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h port_adc_conv.c port_cfg_mtu.h port_flexspi_pin.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group device
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_flexcomm.c fsl_flexcomm.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_iopctl.h fsl_lpadc.c fsl_lpadc.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group MIMXRT685S
    ../../../../../devices/MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    ../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S_cm33.s
  group source
    ../: main.c
    ../../src/: mtu.c mtu.h mtu_crc16.c mtu_crc16.h mtu_pin.h mtu_timer.c mtu_timer.h mtu_uart.h mtu_usart.c
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
