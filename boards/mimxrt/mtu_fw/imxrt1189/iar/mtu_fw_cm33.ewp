# IAR project mtu_fw_cm33.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1189CVM8A_cm33; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../src; ../../../../../devices/MIMXRT1189/utilities/debug_console_lite; ../../../../../devices/MIMXRT1189/drivers; ../../../../../devices/MIMXRT1189; ../../../../../components/uart; ../../../../../components/lists; ../../../../../devices/MIMXRT1189/xip; ../../../xip; ../../../../../devices/MIMXRT1189/drivers/cm33; ../../../../../CMSIS/Core/Include; ../../../../../middleware/mbw
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: boot_firmware.srec
  ILINK.IlinkOutputFile: mtu_fw_cm33.out
  ILINK.IlinkIcfFile: MIMXRT1189xxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1189CVM8A_cm33; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h port_adc_conv.c port_clock_time.c port_flexspi_info.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../devices/MIMXRT1189/: fsl_device_registers.h MIMXRT1189_cm33.h MIMXRT1189_cm33_features.h system_MIMXRT1189_cm33.c system_MIMXRT1189_cm33.h
  group drivers
    ../../../../../devices/MIMXRT1189/drivers/cm33/: fsl_cache.c fsl_cache.h
    ../../../../../devices/MIMXRT1189/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_flexspi.c fsl_flexspi.h fsl_iomuxc.h fsl_lpadc.c fsl_lpadc.h fsl_lpit.c fsl_lpit.h fsl_lpuart.c fsl_lpuart.h fsl_pmu.c fsl_pmu.h fsl_rgpio.c fsl_rgpio.h
  group middleware/mbw
    ../../../../../middleware/mbw/: mbw.c mbw.h mbw_utils.c
  group source
    ../: main.c
    ../../src/: mtu.c mtu.h mtu_adapter.h mtu_bsp.h mtu_config.h mtu_crc16.c mtu_crc16.h mtu_lpit.c mtu_lpuart.c mtu_mem.c mtu_mem.h mtu_mem_nor_device.c mtu_mem_nor_device.h mtu_mem_nor_ops.c mtu_mem_nor_ops.h mtu_systick.c mtu_timer.h mtu_uart.h
  group startup
    ../../../../../devices/MIMXRT1189/iar/: startup_MIMXRT1189_cm33.s
  group utilities
    ../../../../../devices/MIMXRT1189/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
