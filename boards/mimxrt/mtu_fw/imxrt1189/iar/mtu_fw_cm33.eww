<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\mtu_fw_cm33.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>hello_world_demo_cm33</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>hello_world_demo_cm33</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>hello_world_demo_cm33</project>
                <configuration>flexspi_nor_debug</configuration>
            </member>
            <member>
                <project>hello_world_demo_cm33</project>
                <configuration>flexspi_nor_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>release</name>
            <member>
                <project>hello_world_demo_cm33</project>
                <configuration>release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>debug</name>
            <member>
                <project>hello_world_demo_cm33</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flexspi_nor_debug</name>
            <member>
                <project>hello_world_demo_cm33</project>
                <configuration>flexspi_nor_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flexspi_nor_release</name>
            <member>
                <project>hello_world_demo_cm33</project>
                <configuration>flexspi_nor_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
